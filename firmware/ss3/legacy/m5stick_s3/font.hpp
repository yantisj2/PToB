#pragma once
#include <cstdint>
// T096 5x7 face, copied read-only from a3b1563 src/ui.c.
namespace sticks3::font {
/* A compact fixed 5x7 face keeps the renderer freestanding and deterministic. */
static const uint8_t digits[10][5] = {
    {0x3e,0x51,0x49,0x45,0x3e},{0x00,0x42,0x7f,0x40,0x00},
    {0x42,0x61,0x51,0x49,0x46},{0x21,0x41,0x45,0x4b,0x31},
    {0x18,0x14,0x12,0x7f,0x10},{0x27,0x45,0x45,0x45,0x39},
    {0x3c,0x4a,0x49,0x49,0x30},{0x01,0x71,0x09,0x05,0x03},
    {0x36,0x49,0x49,0x49,0x36},{0x06,0x49,0x49,0x29,0x1e}
};
static const uint8_t letters[26][5] = {
    {0x7e,0x11,0x11,0x11,0x7e},{0x7f,0x49,0x49,0x49,0x36},
    {0x3e,0x41,0x41,0x41,0x22},{0x7f,0x41,0x41,0x22,0x1c},
    {0x7f,0x49,0x49,0x49,0x41},{0x7f,0x09,0x09,0x09,0x01},
    {0x3e,0x41,0x49,0x49,0x7a},{0x7f,0x08,0x08,0x08,0x7f},
    {0x00,0x41,0x7f,0x41,0x00},{0x20,0x40,0x41,0x3f,0x01},
    {0x7f,0x08,0x14,0x22,0x41},{0x7f,0x40,0x40,0x40,0x40},
    {0x7f,0x02,0x0c,0x02,0x7f},{0x7f,0x04,0x08,0x10,0x7f},
    {0x3e,0x41,0x41,0x41,0x3e},{0x7f,0x09,0x09,0x09,0x06},
    {0x3e,0x41,0x51,0x21,0x5e},{0x7f,0x09,0x19,0x29,0x46},
    {0x46,0x49,0x49,0x49,0x31},{0x01,0x01,0x7f,0x01,0x01},
    {0x3f,0x40,0x40,0x40,0x3f},{0x1f,0x20,0x40,0x20,0x1f},
    {0x3f,0x40,0x38,0x40,0x3f},{0x63,0x14,0x08,0x14,0x63},
    {0x07,0x08,0x70,0x08,0x07},{0x61,0x51,0x49,0x45,0x43}
};
static const uint8_t punctuation[][5] = {
    {0,0,0,0,0},           /* space */
    {0,0x36,0x36,0,0},    /* : */
    {0x08,0x08,0x08,0x08,0x08}, /* - */
    {0,0x60,0x60,0,0},    /* . */
    {0x20,0x10,0x08,0x04,0x02}, /* / */
    {0x08,0x08,0x3e,0x08,0x08}, /* + */
    {0x02,0x01,0x51,0x09,0x06}, /* ? */
    {0x14,0x14,0x7f,0x14,0x14}, /* # */
    {0x23,0x13,0x08,0x64,0x62}, /* % */
    {0x7f,0x10,0x28,0x44,0x00}, /* k */
    {0x44,0x64,0x54,0x4c,0x44}  /* z */
};
static const uint8_t lower_a[5]={0x20,0x54,0x54,0x54,0x78};
static const uint8_t lower_d[5]={0x38,0x44,0x44,0x48,0x7f};
static const uint8_t lower_e[5]={0x38,0x54,0x54,0x54,0x18};
static const uint8_t lower_m[5]={0x7c,0x04,0x78,0x04,0x78};
static const uint8_t lower_r[5]={0x7c,0x08,0x04,0x04,0x08};
static const uint8_t lower_t[5]={0x04,0x3f,0x44,0x40,0x20};
static const uint8_t arrow_glyph[5]={0,0x22,0x14,0x08,0};
static const uint8_t lower_h[5] = {0x7f,0x08,0x04,0x04,0x78};
static const uint8_t lower_n[5] = {0x7c,0x08,0x04,0x04,0x78};
static const uint8_t lower_u[5]={0x3c,0x40,0x40,0x20,0x7c};
static const uint8_t lower_s[5] = {0x48,0x54,0x54,0x54,0x24};

static const uint8_t *glyph(char c) {
    if (c >= '0' && c <= '9') return digits[c - '0'];
    if (c >= 'A' && c <= 'Z') return letters[c - 'A'];
    switch (c) {
        case '>': return arrow_glyph;
        case 'a': return lower_a;case 'd': return lower_d;case 'e': return lower_e;case 'm': return lower_m;case 'r': return lower_r;case 't': return lower_t;
        case ':': return punctuation[1];
        case '-': return punctuation[2];
        case '.': return punctuation[3];
        case '/': return punctuation[4];
        case '+': return punctuation[5];
        case '?': return punctuation[6];
        case '#': return punctuation[7];
        case '%': return punctuation[8];
        case 'k': return punctuation[9];
        case 'z': return punctuation[10];
        case 'h': return lower_h;
        case 'n': return lower_n;
        case 'u': return lower_u;
        case 's': return lower_s;
        default: return punctuation[0];
    }
}

}

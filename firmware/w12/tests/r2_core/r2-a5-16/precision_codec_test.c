/* Exact complete wire and independent recipient authentication. */
#include "precision_codec.h"
#include <assert.h>
#include <errno.h>
#include <stdio.h>
#include <string.h>
int main(void)
{
 uint8_t keys[4][16],wire[R2_PRECISION_AD_BYTES],bad[R2_PRECISION_AD_BYTES];
 for(unsigned i=0;i<4;i++)for(unsigned j=0;j<16;j++)keys[i][j]=(uint8_t)(i*31+j);
 struct r2_precision_packet p={.root=2,.boot=0x123456789abcdef0ULL,.source_epoch=7,.train=3,.publication=12,.capture_epoch=1,.flags=1,.count=2,.utc_offset_ns=1700000000000000000LL,.created_ns=10000000000ULL,.expires_ns=11000000000ULL,
 .correction={{10,65535,36,159000000,8,11000000000ULL},{11,0,0,159500000,9,11000000000ULL}}};
 assert(!r2_precision_encode(wire,&p,keys));
 static const uint8_t golden[158]={0x9d,0xff,0xff,0xff,0x50,0x32,0x01,0x02,0xf0,0xde,0xbc,0x9a,0x78,0x56,0x34,0x12,0x07,0x00,0x00,0x00,0x03,0x00,0x00,0x00,0x0c,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x01,0x02,0x32,0x00,0x00,0x00,0x2a,0x36,0xfe,0x9c,0x97,0x17,0x00,0xe4,0x0b,0x54,0x02,0x00,0x00,0x00,0x00,0xae,0xa6,0x8f,0x02,0x00,0x00,0x00,0x01,0x00,0x0a,0x00,0x00,0x00,0xff,0xff,0x24,0x01,0xc0,0x25,0x7a,0x09,0x00,0x00,0x00,0x00,0x08,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xae,0xa6,0x8f,0x02,0x00,0x00,0x00,0x0b,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xe0,0xc6,0x81,0x09,0x00,0x00,0x00,0x00,0x09,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xae,0xa6,0x8f,0x02,0x00,0x00,0x00,0x04,0xee,0xcf,0x2d,0x96,0x2a,0x53,0x50,0x97,0xe3,0x81,0x8e,0xf1,0xf6,0x01,0xbc,0x9a,0xd8,0xed,0xf9,0xc9,0xeb,0x7b,0x52,0x85,0xfa,0x25,0x36,0x92,0xe7,0xf2,0xe2};
 assert(!memcmp(wire,golden,sizeof wire));
 for(unsigned i=0;i<4;i++){
  struct r2_precision_packet out;assert(!r2_precision_decode(&out,wire,sizeof(wire),i,keys[i]));
  assert(out.boot==p.boot&&out.utc_offset_ns==p.utc_offset_ns&&out.correction[0].event==65535&&out.correction[1].event==0);
  assert(r2_precision_decode(&out,wire,sizeof(wire),i,keys[(i+1)%4])==-EACCES);
  for(unsigned byte=4;byte<4+R2_PRECISION_BODY_BYTES;byte++)for(unsigned bit=0;bit<8;bit++){
   memcpy(bad,wire,sizeof bad);bad[byte]^=1u<<bit;assert(r2_precision_decode(&out,bad,sizeof bad,i,keys[i]));
  }
 }
 p.utc_offset_ns=INT64_MIN;assert(!r2_precision_encode(wire,&p,keys));struct r2_precision_packet q;assert(!r2_precision_decode(&q,wire,sizeof wire,0,keys[0])&&q.utc_offset_ns==INT64_MIN);
 p.count=3;assert(r2_precision_encode(wire,&p,keys));p.count=2;p.expires_ns=p.created_ns;assert(r2_precision_encode(wire,&p,keys));
 puts("PASS precision codec:158B,4 recipient MACs,all body-bit mutations,65535/0 counters,signed offsets,expiry");
}
